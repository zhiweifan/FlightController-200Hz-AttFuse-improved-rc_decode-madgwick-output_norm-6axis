# Keil uVision project FlightController.uvprojx, settings and files
target FlightController (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FlightController +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Drivers;..\FWLib;..\FWLib\CMSIS;..\User;..\Process;..\Drivers\matrix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FWLib
    ../FWLib/: stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_syscfg.c
    ../FWLib/CMSIS/: misc.c startup_stm32f4xx.s
  group Headers
    ../User/: main.h pid.h
    ../FWLib/: stm32f4xx.h system_stm32f4xx.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_dma.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h
    ../FWLib/CMSIS/: core_cm4.h stm32f4xx_conf.h sys_m4.h misc.h
    ../Drivers/: pwm.h
  group User
    ../User/: main.c time.c dataframe_lib_m4.c usart1.c usart2.c dataframe.c pid.c math_lib.c MadgwickAHRS.c gps_kalman.c
    ../Drivers/: alt_filter.c imu.c
  group Drivers
    ../Drivers/: beep.c led.c pwm.c eeprom.c systime.c
  group process
    ../Process/: process_cmd.c process_ctrl.c process_output.c process_sensor.c process_status_transition.c process_test.c
  group matrix
    ../Drivers/matrix/: kalman_lib.c matrix.c MatrixInv.c ellipsoid.c
